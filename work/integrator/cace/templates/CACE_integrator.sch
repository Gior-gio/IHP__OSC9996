** sch_path: work/integrator/cace/templates/CACE_integrator.sch
**.subckt CACE_integrator
VRESET net1 GND pwl 0 {VDD} 5n {VDD} 6n 0
VSN net3 GND {VSS}
VR net2 GND {vref}
VC Vc GND pwl 0 {vref} 1n {vref} 2n {vctr}
RDD net4 VDD {Rsource} m=1
RSS net3 VSS {Rsource} m=1
RRST net1 RST {Rsource} m=1
RREF net2 Vref {Rsource} m=1
RCTR Vc Vctr {Rsource} m=1
VSP net4 GND {VDD}
XRTAP VSS sub! ptap1 R=262.8 w=0.78e-6 l=0.78e-6
xint Vref VSS VDD RST Vctr VOUT integrator
xCOMP VDD VOUT COMP VSS threshold_comparator
xload VDD COMP X VSS gate_inv_L0d13
* noconn X
**** begin user architecture code

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib CACE{corner_mos}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib CACE{corner_res}
.include CACE{DUT_path}

.temp CACE{temperature}

* Statitical switches
.param mm_ok=CACE{stat_sw}
.param mc_ok=CACE{stat_sw}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.param Vctr = CACE{VDD}
.param Vref = CACE{VDD}/2
.param VDD = CACE{VDD}
.param VSS = 0
.param Rsource = 1m

.save all

.control

* >> Variables <<
let Vhigh = CACE{VDD}
let Vmid = Vhigh * 0.5
let tstop = 50n
let tstep = tstop/1k

* Run transient analysis
tran $&tstep $&tstop

*meas TRAN T_ctr TRIG v(xint.p1) VAL=Vmid rise=2 TARG v(xint.p1) VAL=Vmid rise=3
*let F_ctr = 1 / T_ctr
*meas TRAN T_ref TRIG v(xint.r1) VAL=Vmid rise=2 TARG v(xint.r1) VAL=Vmid rise=3
*let F_ref = 1 / T_ref

*print F_ctr F_ref

meas tran i_INT AVG i(VSP) from=6n to=$&tstop
let i_INT_AVG=-1*i_INT

print i_INT_AVG

meas TRAN T_comp TRIG v(comp) VAL=Vmid rise=5 TARG v(comp) VAL=Vmid rise=6
let F_comp = 1 / T_comp

print F_comp

plot vout
*plot xint.r1 xint.p1
plot comp

echo $&i_INT_AVG $&F_comp> CACE{simpath}/CACE{filename}_CACE{N}.data

.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
