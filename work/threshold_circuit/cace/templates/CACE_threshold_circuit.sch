** sch_path: work/threshold_circuit/cace/templates/CACE_threshold_circuit.sch
**.subckt CACE_threshold_circuit
x2 VDD in out VSS threshold_comparator
* noconn out
VSP VDD GND CACE{VDD}
VIN in GND 0.6
VIS VSS GND {VSS}
**** begin user architecture code

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib CACE{corner_mos}
.include CACE{DUT_path}

.temp CACE{temperature}

* Statitical switches
.param mm_ok=CACE{stat_sw}
.param mc_ok=CACE{stat_sw}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.param VDD = CACE{VDD}
.param VSS = 0




 .control



 let fsig = 100Meg
 let tper = 1/fsig
 let tfr = 0.01 * tper
 let ton = 0.5 * tper - 2 * tfr
 let tstop = 2 * tper
 let tstep = 0.0001 * tper

 alter @VIN[DC] = 0.0
 alter @VIN[PULSE] = [ 0 1.2 0 $&tfr $&tfr $&ton $&tper 0 ]
 op

 tran $&tstep $&tstop


 let VP = 1.2
 let per10 = VP * 0.1
 let per50 = VP * 0.5
 let per90 = VP * 0.9

 meas TRAN t_rise TRIG v(out) VAL=per10 rise=2 TARG v(out) VAL=per90 rise=2
 meas TRAN t_fall TRIG v(out) VAL=per90 fall=2 TARG v(out) VAL=per10 fall=2
 meas TRAN t_delay TRIG v(in) VAL=per50 rise=1 TARG v(out) VAL=per50 fall=1
 meas TRAN T_period TRIG v(out) VAL=per50 rise=1 TARG v(out) VAL=per50 rise=2
 let F_recu = 1 / T_period



* Save output
    echo $&t_rise $&t_fall $&t_delay $&F_recu > CACE{simpath}/CACE{filename}_CACE{N}.data
 .endc


**** end user architecture code
**.ends

* expanding   symbol:  /foss/designs/chipathon_2025/designs/ihp-sg13g2/threshold_circuit/xschem/threshold_comparator.sym # of pins=4
** sym_path: work/threshold_circuit/xschem/threshold_comparator.sym
** sch_path: work/threshold_circuit/xschem/threshold_comparator.sch
.subckt threshold_comparator VDD Vin Vout VSS
*.iopin VDD
*.iopin VSS
*.ipin Vin
*.opin Vout
XM2 Vx Vin VDD VDD sg13_lv_pmos w=2u l=0.13u ng=1 m=2 mm_ok=1
XM1 Vx Vin VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=2 mm_ok=1
XM3 Vout Vx VDD VDD sg13_lv_pmos w=2u l=0.13u ng=1 m=2 mm_ok=1
XM4 Vout Vx VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=2 mm_ok=1
.ends

.GLOBAL GND
.end
