** sch_path: work/LIF_neuron/cace/templates/CACE_LIF_neuron_x1_TB.sch
**.subckt CACE_LIF_neuron_x1_TB
xLIF VDD Vx MEM RST SPIKE VSS Vref COMP LIF_neuron
RIN Vctr Vx 100k m=1
* noconn MEM
VR net1 GND {vref}
VC net2 GND pwl 0 {vref} 20n {vref} 21n {vctr}
RREF net1 Vref {Rsource} m=1
RCTR net2 Vctr {Rsource} m=1
XRTAP VSS sub! ptap1 R=262.8 w=0.78e-6 l=0.78e-6
Cload SPIKEB VSS {Cload} m=1
Cload1 COMPB VSS {Cload} m=1
xSPKB VDDB SPIKE SPIKEB VSS gate_buff_pad
xCOMPB VDDB COMP COMPB VSS gate_buff_pad
VRESET net3 GND pwl 0 {VDD} 10n {VDD} 11n 0
VSN net4 GND {VSS}
RDD net5 VDD {Rsource} m=1
RSS net4 VSS {Rsource} m=1
RRST net3 RST {Rsource} m=1
VSP net5 GND {VDD}
RDD1 net6 VDDB {Rsource} m=1
VSP1 net6 GND {VDD}
**** begin user architecture code



.param VDD = CACE{VDD}
.param VSS = 0
.param vctr = CACE{VDD}/2
.param vref = CACE{VDD}
.param Cload = 20p
.param Rsource = 1m

.save all

.control

* >> Variables <<
let Vhigh = CACE{VDD}
let Vmid = Vhigh * 0.5

let tstop = 0.1u
let tstep = tstop/2.5k

* Run transient analysis
tran $&tstep $&tstop uic

let IDD = -1*i(VSP)
meas tran I_avg AVG IDD from=tstep to=tstop
let P_avg = abs(I_avg*Vhigh)

meas TRAN T_spk TRIG v(SPIKE) VAL=Vmid rise=2 TARG v(SPIKE) VAL=Vmid rise=3
let F_spk = 1 / T_spk
let E_spk = P_avg/F_spk*1e12

echo $&F_spk $&I_avg $&P_avg $&E_spk> CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib CACE{corner_mos}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib CACE{corner_res}
.include CACE{DUT_path}

.temp CACE{temperature}

* Statitical switches
.param mm_ok=CACE{stat_sw}
.param mc_ok=CACE{stat_sw}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
