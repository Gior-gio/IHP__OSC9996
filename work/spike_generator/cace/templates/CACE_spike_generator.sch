** sch_path: work/spike_generator/cace/templates/CACE_spike_generator.sch
**.subckt CACE_spike_generator
VSP VDD GND CACE{VDD}
VIS VSS GND {VSS}
x1 VDD in Vspk Vrst VSS VSS spike_generator
VIN in GND 0.6
* noconn Vspk
* noconn Vrst
**** begin user architecture code

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib CACE{corner_mos}
.include CACE{DUT_path}

.temp CACE{temperature}

* Statitical switches
.param mm_ok=CACE{stat_sw}
.param mc_ok=CACE{stat_sw}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.param VDD = CACE{VDD}
.param VSS = 0




 .control



 let fsig = 100Meg
 let tper = 1/fsig
 let tfr = 0.01 * tper
 let ton = 0.5 * tper - 2 * tfr
 let tstop = 2 * tper
 let tstep = 0.001 * tper

 alter @VIN[DC] = 0.0
 alter @VIN[PULSE] = [ 0 1.2 0 $&tfr $&tfr $&ton $&tper 0 ]


 tran $&tstep $&tstop
 meas TRAN width_pulse  TRIG v(in)  VAL=0.6 rise=2  TARG v(Vspk) VAL=0.6 fall=2
 let i_VSPIKE = -1*i(VSP)
 meas tran i_VSPIKE_AVG AVG i_VSPIKE from=tstep to=tstop

* Save output
    echo $&width_pulse $&i_VSPIKE_AVG > CACE{simpath}/CACE{filename}_CACE{N}.data
 .endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
